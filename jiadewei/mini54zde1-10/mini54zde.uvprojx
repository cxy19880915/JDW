# Keil uVision project mini54zde.uvprojx, settings and files
target mini54zde (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Mini54ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: mini54zde +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\RTE\Device\Mini54ZDE;.\CMSIS\Include;.\module\inc;.\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group user
    ./User/: main.c task.c KEY_Scan.c TAS5754.c Encoder.c Bluetooth.c ir.c
  group module
    ./module/src/: i2c_software_gpio.c
software components: Device:Driver:ADC 3.01.001, Device:Driver:CLK 3.01.001, Device:Driver:GPIO 3.01.001, Device:Driver:I2C 3.01.001, Device:Driver:SYS 3.01.001, Device:Driver:Timer 3.01.001, Device:Startup 3.01.001
