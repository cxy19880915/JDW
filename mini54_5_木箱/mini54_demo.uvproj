# Keil uVision project mini54_demo.uvproj, settings and files
target mini54zde (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Mini54ZDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: mini54_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\LIB\Include;.\LIB\Mini51Series\Include;.\LIB\StdDriver\inc;.\INC
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --entry Reset_Handler
  group src
    ./SRC/: AT24C02.c bd3490.c Bluetooth.c demo.c Encoder.c i2c_gpio.c ir.c KEY_Scan.c pcm9211.c task.c usb.c
  group CMSIS
    ./LIB/StdDriver/src/: clk.c gpio.c sys.c retarget.c timer.c
    ./LIB/Mini51Series/Source/: system_Mini51Series.c
  group New Group
    ./LIB/: startup_Mini51Series.s
