# Keil uVision project GPIO.uvproj, settings and files
target N76E003 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: GPIO +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include;.\Include
  group Source Group 1
    ./N76E003/Code/: DEMO.C sysinit.c task_deal.c
  group Common
    ./Common/: Common.c Delay.c Adc.c Timer0.c I2C_M.c IR_recive.c Bluetooth.c
    ./N76E003/Code/: MOVIE-16.02.23.C MUSIC-16.02.23.C VOICE-16.02.23.C channel_switch.c
  group Startup
    ./Startup/: STARTUP.A51
