# Keil uVision project demo_mini.uvprojx, settings and files
target mini54zde (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Mini54ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: demo_mini
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc;.\lib\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group src
    ./src/: i2c_gpio.c ir.c KEY_Scan.c task.c Bluetooth.c demo.c Encoder.c Headset.c
  group inc
    ./lib/inc/: pwm.h spi.h sys.h timer.h uart.h wdt.h i2c.h gpio.h fmc.h clk.h adc.h acmp.h
    ./inc/: AIOSPreset.h Bluetooth.h Encoder.h FM160212.h Headset.h ir.h KEY_Scan.h NTP8230.h TAS5754.h task.h i2c_gpio.h
software components: CMSIS:CORE 5.0.1, Device:Driver:ACMP 3.01.002, Device:Driver:ADC 3.01.002, Device:Driver:CLK 3.01.002, Device:Driver:FMC 3.01.002, Device:Driver:GPIO 3.01.002, Device:Driver:I2C 3.01.002, Device:Driver:PWM 3.01.002, Device:Driver:SYS 3.01.002, Device:Driver:Timer 3.01.002, Device:Startup 3.01.002
